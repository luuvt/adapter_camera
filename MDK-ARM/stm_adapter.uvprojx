# Keil uVision project stm_adapter.uvprojx, settings and files
target stm_adapter (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: stm_adapter
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;..\Drivers\HM_SERIAL;..\Drivers\RF_315;..\Drivers\Button_driver;..\Drivers\adapter_camera_config;..\Drivers\stm32f1xx_flash_if;..\Drivers\adapter_camera_config;..\Drivers\pir
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0xfc00
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_tim.c stm32f1xx_hal_dma.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal.c stm32f1xx_hal_adc.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_flash.c stm32f1xx_hal_rcc.c stm32f1xx_hal_pwr.c stm32f1xx_hal_uart.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_cortex.c
  group Serial_debug
    ../Drivers/HM_SERIAL/: debug_console.c hm_serial_uart8.c serial_debug_config.c user_debug.c
  group Config_adapter_camera
    ../Drivers/adapter_camera_config/: adapter_camera_config.cpp adapter_camera_data_conf.cpp adapter_camera_middle_core.cpp
    ../Drivers/stm32f1xx_flash_if/: stm32f1xx_flash_if.c
  group RF_315
    ../Drivers/RF_315/: RCSwitch.cpp
  group Button_driver
    ../Drivers/Button_driver/: button_driver.c
  group Application/CppUser
    ./: main.cpp
  group Application/User
    ../Src/: tim.c stm32f1xx_it.c dma.c gpio.c adc.c iwdg.c stm32f1xx_hal_msp.c usart.c
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group PIR
    ../Drivers/pir/: di_debounce.c
software components: CMSIS:CORE 4.1.0
